# Keil uVision project Blinky.uvprojx, settings and files
target SN32F420 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SN32F424T SONiX
  pack: SONiX.SN32F4_DFP.1.1.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x7FC0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x7fc0
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: Blinky.c LED.c PFPA.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.0.5
