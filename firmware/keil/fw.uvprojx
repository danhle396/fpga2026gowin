# Keil uVision project fw.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../src/: app_main.c diag.c board.c spi_fpga.c spi_frame.c crc.c preprocess.c blocks.c safety.c gyro_cal.c app_core.c pwr_btn.c i2c0.c imu.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
