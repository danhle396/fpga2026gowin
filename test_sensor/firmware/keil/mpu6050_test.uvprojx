# Keil uVision project mpu6050_test.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mpu6050_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../: test_main.c mpu6050.c i2c_soft.c board_sn32f407.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
